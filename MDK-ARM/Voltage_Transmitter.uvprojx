# Keil uVision project Voltage_Transmitter.uvprojx, settings and files
target Voltage_Transmitter (6160000::V6.16::ARMCLANG)
  device: STM32F373R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Voltage_Transmitter +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F373xC
  c include: ..\;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F3xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../: main.c system_stm32f3xx.c
  group MDK-ARM
    ../: startup_stm32f373xc.s
software components: CMSIS:CORE 5.5.0
